<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2084000</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>bitsInLast</key><value>1</value></param>
<param><key>_source_code</key><value>"""
Serialize source

Takes a predefined string, and outputs it as a serial OOK coded bitsream.....
"""

import numpy as np
import sys
import pmt

from gnuradio import gr


class blk(gr.sync_block):

    def __init__(self, bitsInLast = 1, repeat = 5, gap = 40):
        """
        bitsInLast - Number of bits to send from tha last byte
        repeat - number of times to repeat the message
        gap = the gap to use between messages
        """
        
        gr.sync_block.__init__(
            self,
            name='Serialize Source', 
            in_sig=None, 
            out_sig=[np.byte]
        )
        
        self.message_port_register_in(pmt.intern('msg_in'))
        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
 
        self.bitsInLast = bitsInLast
	self.items = [np.byte(0xff), np.byte(0xff), np.byte(0xea), np.byte(0x80)] #ea on eb off
        self.sent = 0
        self.send = 0
	self.repeat = repeat
        self.gap = gap

    def work(self, input_items, output_items):
            
        retcnt = 0
        if ~self.sent &amp; self.send &amp; 0x01:
        
                if len(output_items[0]) &gt; (len(self.items)*8*5+self.gap)*self.repeat:
                        
                        for x in range(0, self.repeat):
                                
                                #output_items[0][retcnt] = 1
                                #output_items[0][retcnt+1:retcnt+11] = 0
                                #retcnt = retcnt + 11
                                for i in range(0, len(self.items)):
                                        elem = self.items[i]
                                        last = 8
                                        if i == len(self.items)-1:
                                                last = self.bitsInLast
                                        #print i
                                        sys.stdout.write("%x " % (elem))
                                        for n in range(0,last):
                                                #sys.stdout.write("%i " % (n))
                                                #self.buffer.append(self.items[i] &amp; 0x01) # [i*7+n]
                                                if elem &amp; 0x80:
                                                        output_items[0][retcnt] = 1
                                                        output_items[0][retcnt+1:retcnt+5] = 0
                                                        retcnt = retcnt + 5
                                                        #output_items[0][retcnt] = 1
                                                        #output_items[0][retcnt+1:retcnt+6] = 0
                                                        #retcnt = retcnt + 6 
                                                else:
                                                        output_items[0][retcnt:retcnt+3] = 1
                                                        output_items[0][retcnt+5] = 0 
                                                        retcnt = retcnt + 5 
                                                        #output_items[0][retcnt] = 1
                                                        #output_items[0][retcnt+1:retcnt+3] = 0 
                                                        #retcnt = retcnt + 3 
                                                #output_items[0][i*7+n] = elem &amp; 0x01
                                                elem =  elem &lt;&lt; 1
                                                #retcnt = retcnt + 1
                                                #self.count = self.count + 1
                                #output_items[0][retcnt] = 1
                                #retcnt = retcnt + 1
                                output_items[0][retcnt:retcnt+self.gap] = 0
                                retcnt = retcnt + self.gap         
                                
                        self.sent = 1
                        self.send = 0 #forresten det kanske funka bara att det inte sags pa time sink
                        #print self.sent
        elif ~self.send &amp; 0x01:
                self.sent = 0
                #self.send = 0
                #output_items[0][:] = 0
                #retcnt = len(output_items[0])
                retcnt = 0 
        else:
                #output_items[0][:] = 0
                #retcnt = len(output_items[0])
                retcnt = 0 
        #retcnt = self.count
        #self.count = 0
        #print self.buffer
        #output_items[0][0:len(self.buffer)] = 1
        #output_items[0][:] = 1
        #self.buffer[:] = []
        
        return retcnt

    def handle_msg(self, msg):
         self.items = bytearray.fromhex(pmt.symbol_to_string(msg))
         self.send = 1
</value></param>
<param><key>gap</key><value>50</value></param>
<param><key>repeat</key><value>1</value></param>
</block>
<block>
<key>pluto_sink</key>
<param><key>id</key><value>pluto_sink_0</value></param>
<param><key>attenuation</key><value>0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>uri</key><value>ip:pluto.local</value></param>
<param><key>frequency</key><value>433900000</value></param>
<param><key>bandwidth</key><value>20000000</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>label</key><value>Message (in hex)</value></param>
<param><key>is_pair</key><value>False</value></param>
<param><key>is_static</key><value>False</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ff ff eb 80</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0</source_block_id><sink_block_id>pluto_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>msg</source_key><sink_key>msg_in</sink_key></connection>
</flow_graph>

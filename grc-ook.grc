<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2084000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>short_pulse</value></param>
<param><key>value</key><value>280</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>85*short_pulse*samp_rate/100000000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>short_pulse*2*samp_rate/1000000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>0.1</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.05</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Python OOK Demodulate
Deserialize Sink

Takes a bit stream and uses a deleayd version of it as a strobe signal
"""

import numpy as np
import sys

from gnuradio import gr


class blk(gr.sync_block):

    def __init__(self, reset_limit = 2000):
        """reset_limit - expect next pulse within x number of samples"""
        gr.sync_block.__init__(
            self,
            name='Python OOK Demod',
            in_sig=[np.byte, np.byte], 
            out_sig=None
        )
        
	self.buffer = np.byte(0)
	self.count = 0
	self.timeout = 0
	self.reset_limit = reset_limit

    def work(self, input_items, output_items):
        
	if np.any(input_items[1][:] &gt; 0):
        	for i in range (1, len(input_items[0])):
			self.timeout = self.timeout + 1
			if self.timeout == self.reset_limit and self.count &gt; 0:
				sys.stdout.write("%x \n" % (self.buffer &lt;&lt; (8 - self.count))) 
				self.buffer = 0
				self.count = 0
			if input_items[1][i] &amp; 0x01 &amp; ~input_items[1][i-1]:
				self.timeout = 0
				self.buffer = (self.buffer &lt;&lt; 1) | (~input_items[0][i] &amp; 0x01)
				self.count = self.count + 1

				if self.count == 8:
					sys.stdout.write("%x " % (self.buffer)) 		
					self.buffer = 0
					self.count = 0		
		
	else:
		if self.timeout &gt; 0:
			self.timeout = 0
			if self.count &gt; 0:
				sys.stdout.write("%x \n" % (self.buffer &lt;&lt; (8 - self.count)))
				self.buffer = 0
				self.count = 0
			else:
				print ""
        return len(input_items[0])
	
</value></param>
<param><key>reset_limit</key><value>4*short_pulse*samp_rate/1000000</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>bitsInLast</key><value>1</value></param>
<param><key>_source_code</key><value>"""
Python OOK modulate
Serialize source

Takes a predefined string, and outputs it as a serial OOK coded bitsream.....
"""

import numpy as np
import pmt

from gnuradio import gr


class blk(gr.sync_block):

    def __init__(self, bitsInLast = 1, repeat = 5, gap = 40, hi_1 = 1, lo_1 = 4, hi_0 = 3, lo_0 = 2):
        """
        bitsInLast - Number of bits to send from tha last byte
        repeat - number of times to repeat the message
        gap = the gap to use between messages
        hi_1 = the number of 1 samples in a logic hi
        lo_1 = the number of 0 samples in a logic hi
        hi_0 = the number of 1 samples in a logic low
        lo_0 = the number of 0 samples in a logic low
        """
        
        gr.sync_block.__init__(
            self,
            name='Python OOK modulate', 
            in_sig=None, 
            out_sig=[np.byte]
        )
        
        self.message_port_register_in(pmt.intern('msg_in'))
        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
 
        self.bitsInLast = bitsInLast
	self.items = [np.byte]
        self.sent = 0
        self.send = 0
	self.repeat = repeat
        self.gap = gap
        self.hi_1 = hi_1
        self.lo_1 = lo_1
        self.hi_0 = hi_0
        self.lo_0 = lo_0 

    def work(self, input_items, output_items):
            
        retcnt = 0
        if ~self.sent &amp; self.send &amp; 0x01:
        
                if len(output_items[0]) &gt; (len(self.items)*8*5+self.gap)*self.repeat:
                        
                        for x in range(0, self.repeat):
                                
                                for i in range(0, len(self.items)):
                                        elem = self.items[i]
                                        last = 8
                                        if i == len(self.items)-1:
                                                last = self.bitsInLast
                                        
                                        for n in range(0,last):

                                                if elem &amp; 0x80:
                                                        output_items[0][retcnt:retcnt+self.hi_1] = 1
                                                        output_items[0][retcnt+self.hi_1:retcnt+self.hi_1 +self.lo_1] = 0
                                                        retcnt = retcnt + self.hi_1 + self.lo_1
                                                         
                                                else:
                                                        output_items[0][retcnt:retcnt+self.hi_0] = 1
                                                        output_items[0][retcnt+self.hi_0:retcnt+self.hi_0+self.lo_0] = 0 
                                                        retcnt = retcnt + self.hi_0 + self.lo_0
                                                        
                                                elem =  elem &lt;&lt; 1
                                                
                                output_items[0][retcnt:retcnt+self.gap] = 0
                                retcnt = retcnt + self.gap         
                                
                        self.sent = 1
                        self.send = 0

        elif ~self.send &amp; 0x01:
                self.sent = 0
                retcnt = 0 
        else:
                retcnt = 0 
        
        return retcnt

    def handle_msg(self, msg):
            self.items = bytearray.fromhex(pmt.symbol_to_string(msg))
            self.send = 1
</value></param>
<param><key>gap</key><value>50</value></param>
<param><key>hi_0</key><value>3</value></param>
<param><key>hi_1</key><value>1</value></param>
<param><key>lo_0</key><value>2</value></param>
<param><key>lo_1</key><value>4</value></param>
<param><key>repeat</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>waveman 240us, 1:4, 3:2 -&gt;1400us fixed period
fineoffset wh2 500us, 1:2, 3:2  -&gt; 100us fixed gap</value></param>
<param><key>note</key><value>Pulse width in us</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>comment</key><value>ff ff ea 80 on
ff ff eb 80 off</value></param>
<param><key>note</key><value>Waveman remote</value></param>
</block>
<block>
<key>pluto_sink</key>
<param><key>id</key><value>pluto_sink_0</value></param>
<param><key>attenuation</key><value>10</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>uri</key><value>ip:pluto.local</value></param>
<param><key>frequency</key><value>433920000</value></param>
<param><key>bandwidth</key><value>200000</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>pluto_source</key>
<param><key>id</key><value>pluto_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>uri</key><value>ip:pluto.local</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain</key><value>"slow_attack"</value></param>
<param><key>frequency</key><value>433920000</value></param>
<param><key>manual_gain</key><value>64.0</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>bandwidth</key><value>200000</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>label</key><value>Message (in hex)</value></param>
<param><key>is_pair</key><value>False</value></param>
<param><key>is_static</key><value>False</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ff ff ea 80</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0</source_block_id><sink_block_id>pluto_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_float_to_uchar_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>msg</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
